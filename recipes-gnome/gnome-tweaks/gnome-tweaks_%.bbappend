# Python bytecode embeds TMPDIR paths - harmless, skip QA check
INSANE_SKIP:${PN} += "buildpaths"
