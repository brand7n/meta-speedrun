# Bump to 0.2.0 - mutter 48.0 requires libdisplay-info >= 0.2
# NXP pins 0.1.1 which is too old for GNOME 48
PV = "0.2.0"
SRCREV = "66b802d05b374cd8f388dc6ad1e7ae4f08cb3300"
