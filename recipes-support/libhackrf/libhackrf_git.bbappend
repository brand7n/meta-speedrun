# Fix: hackrf repo renamed master -> main, old SRCREV gone
SRC_URI = "git://github.com/mossmann/hackrf.git;branch=main;protocol=https"
SRCREV = "1cfe7dfe98d333450217d50e3f3a1ad0702e000f"
PV = "2026.01.3"
