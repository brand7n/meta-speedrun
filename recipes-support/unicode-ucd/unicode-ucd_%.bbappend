# Fix checksums for upstream license file change (unicode.org updated copyright year to 1991-2026)
SRC_URI[ucd-license.sha256sum] = "e7a93b009565cfce55919a381437ac4db883e9da2126fa28b91d12732bc53d96"
LIC_FILES_CHKSUM = "file://${S}/ucd-license-v3.txt;md5=3049f4ad14be1ebf8c80a93d9d32b2d6"
