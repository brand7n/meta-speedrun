# Remove gstreamer1.0-rtsp-server - freedesktop.org download unreachable
RDEPENDS:${PN}:remove = "gstreamer1.0-rtsp-server"
